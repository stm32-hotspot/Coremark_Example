# Keil uVision project coremark_test.uvprojx, settings and files
target coremark_test (6160000::V6.16::.\ArmCompiler6.16)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: coremark_test +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c misc: -mcpu=cortex-m33 -Omax
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  link misc: -Omax
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c core_main.c core_util.c core_portme.c core_matrix.c core_state.c core_list_join.c cvt.c ee_printf.c
    ../Core/Inc/: core_portme.h coremark.h
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
software components: CMSIS:CORE 5.6.0
